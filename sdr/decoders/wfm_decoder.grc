options:
  parameters:
    generate_options: no_gui
    id: wfm_decoder
    output_language: python
    run_options: run
    title: Fm decoder
  states: {}

blocks:
- name: duration
  id: variable
  parameters:
    value: '60'
  states: {}
- name: out_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: sample_rate
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '128'
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: tmp.raw
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(sample_rate * duration * 2)
    type: byte
  states: {}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: out_rate/sample_rate
    type: fff
  states: {}

connections:
- [analog_wfm_rcv_0, '0', pfb_arb_resampler_xxx_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_interleaved_char_to_complex_0, '0']
- [blocks_file_source_0, '0', blocks_head_0, '0']
- [blocks_head_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', analog_wfm_rcv_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_null_sink_0, '0']
- [pfb_arb_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
